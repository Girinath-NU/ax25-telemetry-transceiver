options:
  parameters:
    generate_options: qt_gui
    id: ax25_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '200000000'
    value: '200000'
  states: {}
- name: Center_Freq
  id: variable_qtgui_range
  parameters:
    start: '88000000'
    step: '1'
    stop: 108e6
    value: 91e6
  states: {}
- name: Gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 48e6
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/girinath/RF Lab/CubeSat Telemetry/V2/TX/packet.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: '125'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: BW
    center_freq0: Center_Freq
    gain0: '100'
    samp_rate: 1e6
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
